C1 1 0 200
R1 1 2 0.05
R2 2 3 0.4
C2 2 0 7000
V2 3 0 Symbolic
I1 0 1 Symbolic
